# Repository TNCTRobocon/mdu2018

## EAGLE design mdu29.brd

Parts:
C1, C3: 1uF; 1608
C2, C4, C5, C6, C9, C10, C12, C13, C14, C15, C16, C17, C18, C19: 0.1uF; 1608
C7, C8: 22p; 1608
C11, C20: 2.2uF; 1608
D1, D2: ZENER-SOD523; SOD523
HD1: 1X4L; 1X4-L
HD2: 2X4I; 2X4-I
IC1: MIC5504; SOT95P270X145-5N
IC2: LM4040; SOT23
J1: FTSH-105-01-L-DV-K-TR; CON10_2X5_DUK_FTSH
LED1, LED2, LED3, LED4: LED1608; 1608
R1, R4, R5, R20, R21, R23, R24: 330ohm; 1608
R2, R6, R7, R8, R9, R11, R12, R13, R15, R17, R18: 10k; 1608
R3, R14, R16, R19: 1kohm; 1608
R10: 330; 1608
R22, R25: 100; 1608
RV1: 10k B; RV
S1: SWS008; SMS-008
SW1, SW2, SW3: TACTSW1; PUSHSW-1
U1: STM32F401VCT6LQFP-100-M; LQFP-100-M
X1: MINI-USB-UX60-MB-5ST; UX60-MB-5ST
X2: 8MHz; XTAL

Connections:
+3V3: C3.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, HD2.2, IC1.5 (VOUT), J1.1, R2.1, R6.2, R7.2, R8.1, R9.1, R11.2, R12.2, R13.2, R15.2, R17.2, R18.2, R22.1, R25.2, RV1.1, U1.6 (VBAT), U1.11 (VDD_5), U1.22 (VDDA), U1.28 (VDD_4), U1.50 (VDD_1), U1.75 (VDD_2), U1.100 (VDD_3); also elsewhere on the board
+5V: C1.1, D1.K, D2.K, IC1.1 (VIN), IC1.3 (EN); also elsewhere on the board
A1: U1.88 (PD7); also elsewhere on the board
A2: U1.3 (PE4); also elsewhere on the board
A3: U1.18 (PC3); also elsewhere on the board
A4: U1.44 (PE13); also elsewhere on the board
B1: U1.80 (PC12); also elsewhere on the board
B2: U1.97 (PE0); also elsewhere on the board
B3: U1.9 (PC15-OSC32_OUT); also elsewhere on the board
B4: U1.38 (PE7); also elsewhere on the board
BATERR: R24.2, U1.51 (PB12)
BATSTA: R23.2, U1.52 (PB13)
BOOT0@SYS: R17.1, S1.10, U1.94 (BOOT0)
BOOT1@SYS: R18.1, S1.9, U1.37 (PB2)
C1@ANA: U1.29 (PA4); also elsewhere on the board
C2@ANA: U1.30 (PA5); also elsewhere on the board
C3@ANA: U1.31 (PA6); also elsewhere on the board
C4@ANA: U1.32 (PA7); also elsewhere on the board
CD1: U1.82 (PD1); also elsewhere on the board
CD2: U1.1 (PE2); also elsewhere on the board
CD3: U1.16 (PC1); also elsewhere on the board
CD4: U1.41 (PE10); also elsewhere on the board
CLKIN: C8.2, U1.12 (OSC_IN), X2.1
CLKOUT: C7.2, U1.13 (OSC_OUT), X2.2
CTS2@UART: HD2.7, U1.84 (PD3)
DM@USB: U1.70 (PA_11), X1.2
DP@USB: U1.71 (PA_12), X1.3
EA1: U1.83 (PD2); also elsewhere on the board
EA2: U1.2 (PE3); also elsewhere on the board
EA3: U1.17 (PC2); also elsewhere on the board
EA4: U1.43 (PE12); also elsewhere on the board
EB1: U1.81 (PD0); also elsewhere on the board
EB2: U1.98 (PE1); also elsewhere on the board
EB3: U1.15 (PC0); also elsewhere on the board
EB4: U1.39 (PE8); also elsewhere on the board
EIO0: HD2.1, U1.79 (PC11)
EIO1: HD2.3, U1.78 (PC10)
ENCL1: U1.92 (PB6); also elsewhere on the board
ENCL2: U1.7 (PC13-TAMPER-RTC); also elsewhere on the board
ENCL3: U1.35 (PB0); also elsewhere on the board
ENCL4: U1.45 (PE14); also elsewhere on the board
ERR1: U1.93 (PB7); also elsewhere on the board
ERR2: U1.8 (PC14-OSC32_IN); also elsewhere on the board
ERR3: U1.36 (PB1); also elsewhere on the board
ERR4: U1.46 (PE15); also elsewhere on the board
GND: C1.2, C2.1, C3.2, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, HD1.2, HD2.4, IC1.2 (GND), IC2.2 (VSS), J1.3, J1.5, J1.9, LED1.K, LED2.K, LED3.K, LED4.K, R10.2, S1.1, S1.2, S1.3, S1.4, S1.5, S1.6, S1.7, S1.8, SW1.2-1, SW1.2-2, SW2.2-1, SW2.2-2, SW3.2-1, SW3.2-2, U1.10 (VSS_5), U1.20 (VREF-), U1.27 (VSS_4), U1.49 (VSS_1), U1.74 (VSS_2), U1.99 (VSS_3), X1.5; also elsewhere on the board
KEY: J1.7
unnamed: R4.1, SW2.1-1, SW2.1-2
unnamed: R1.1, SW1.1-1, SW1.1-2
unnamed: C2.2, R1.2, R2.2, R3.1
unnamed: LED1.A, R20.1
unnamed: LED2.A, R21.1
unnamed: R5.1, SW3.1-1, SW3.1-2
unnamed: LED3.A, R23.1
unnamed: LED4.A, R24.1
unnamed: D1.A, HD1.1
unnamed: C20.2, U1.73 (VCAP_2)
unnamed: C11.2, U1.48 (VCAP_1)
unnamed: C10.2, R25.1, U1.19 (VSSA)
unnamed: C9.2, IC2.1 (VREF), R22.2, U1.21 (VREF+)
unnamed: C4.2, R5.2, R8.2, R14.1
unnamed: C5.2, R4.2, R9.2, R16.1
unnamed: C6.2, R10.1, R19.1, RV1.2, RV1.3
NRST@SYS: R14.2, U1.14 (NRST)
P1@PWM: U1.95 (PB8); also elsewhere on the board
P2@PWM: U1.96 (PB9); also elsewhere on the board
P3@PWM: U1.5 (PE6); also elsewhere on the board
P4@PWM: U1.4 (PE5); also elsewhere on the board
RTS2@UART: HD2.5, U1.85 (PD4)
RX1@UART: HD1.3, U1.26 (PA3)
RX2@UART: HD2.6, U1.87 (PD6)
RXSTA: R21.2, U1.53 (PB14)
SA0: R6.1, S1.16, U1.68 (PA_9)
SA1: R7.1, S1.15, U1.67 (PA_8)
SA2: R11.1, S1.14, U1.66 (PC9)
SA3: R12.1, S1.13, U1.65 (PC8)
SB0: R13.1, S1.12, U1.62 (PD15)
SB1: R15.1, S1.11, U1.61 (PD14)
SW0: R16.2, U1.91 (PB5)
SW1: R3.2, U1.47 (PB10)
TCK: J1.4, U1.76 (PA14)
TDI: J1.8, U1.77 (PA15)
TDO: J1.6, U1.89 (PB3)
TMS: J1.2, U1.72 (PA_13)
TRST: J1.10, U1.90 (PB4)
TX1@UART: HD1.4, U1.25 (PA2)
TX2@UART: HD2.8, U1.86 (PD5)
TXSTA: R20.2, U1.54 (PB15)
USB_ID: X1.4
USB_VBUS: D2.A, X1.1
VM@ANA: U1.33 (PC4); also elsewhere on the board
VT@ANA: R19.2, U1.34 (PC5)
X1@ENC: U1.63 (PC6); also elsewhere on the board
X2@ENC: U1.59 (PD12); also elsewhere on the board
X3@ENC: U1.40 (PE9); also elsewhere on the board
X4@ENC: U1.23 (PA0-WKUP); also elsewhere on the board
Y1@ENC: U1.64 (PC7); also elsewhere on the board
Y2@ENC: U1.60 (PD13); also elsewhere on the board
Y3@ENC: U1.42 (PE11); also elsewhere on the board
Y4@ENC: U1.24 (PA1); also elsewhere on the board
Z1: U1.58 (PD11); also elsewhere on the board
Z2: U1.57 (PD10); also elsewhere on the board
Z3: U1.56 (PD9); also elsewhere on the board
Z4: U1.55 (PD8); also elsewhere on the board

Notes on the sheet:
電源見直し >バッテリー電流計測 >電源遮断器 >USB+バッテリー電源+ハブ電源をダイオードでつなぐ >電流計測 >電圧計測 マイコン >バイパスコンデンサ >基準電源IC >boot selector 追加 >リセットスイッチ モータIC >ジャンパーピンの廃止 >ヒートシンクの追加もしくはライブラリを探す >配線をきれいに >
簡易LPF
基準電圧回路
Jtag I/F
設定回路 (Address,Cell,Boot)
周辺機器接続回路
基準周波数生成回路
リセット回路
デバック支援回路
Blue

Parts:
C21, C22, C27, C28, C33: 1000pF; 1608
C23, C24, C29, C30: 0.1uF; 1608
C25, C26, C31, C32: 220uF; ES-12.5
CON1, CON2, CON3, CON4: CON-5; 5-L
LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: LED1608; 1608
PD1, PD2, PD3, PD4: VNH5019
R26, R27, R28, R29, R30, R31, R58, R59, R60, R61, R62, R63: 10ohm; 1608
R32, R33, R64, R65: 3.9kohm; 1608
R34, R35, R66, R67: 820ohm; 1608
R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79: 47kohm; 1608
R48, R50, R80, R87: 10[khom]; 1608
R49, R53, R54, R57: 330ohm; 1608
R51, R52, R55, R56, R81, R83, R88, R89: 10kohm; 1608
R82, R84, R85, R86: 330; 1608
R90: 11kohm; 1608
R91: 1kohm; 1608
R92: 3kohm; 1608

Connections:
+3V3: R40.2, R41.2, R44.2, R45.2, R48.2, R50.2, R51.2, R52.2, R55.2, R56.2, R72.2, R73.2, R76.2, R77.2, R80.2, R81.2, R83.2, R87.2, R88.2, R89.2; also elsewhere on the board
+5V: CON1.P$1 (1), CON2.P$1 (1), CON3.P$1 (1), CON4.P$1 (1); also elsewhere on the board
A1: R30.1; also elsewhere on the board
A2: R60.1; also elsewhere on the board
A3: R27.1; also elsewhere on the board
A4: R63.1; also elsewhere on the board
B1: R31.1; also elsewhere on the board
B2: R61.1; also elsewhere on the board
B3: R28.1; also elsewhere on the board
B4: R58.1; also elsewhere on the board
C1@ANA: C22.1, R33.2; also elsewhere on the board
C2@ANA: C27.1, R64.2; also elsewhere on the board
C3@ANA: C21.1, R32.2; also elsewhere on the board
C4@ANA: C28.1, R65.2; also elsewhere on the board
CD1: PD2.6 (CS_DIS), R37.2; also elsewhere on the board
CD2: PD3.6 (CS_DIS), R68.2; also elsewhere on the board
CD3: PD1.6 (CS_DIS), R36.2; also elsewhere on the board
CD4: PD4.6 (CS_DIS), R69.2; also elsewhere on the board
EA1: PD2.5 (ENA/DIAGA), R45.1; also elsewhere on the board
EA2: PD3.5 (ENA/DIAGA), R76.1; also elsewhere on the board
EA3: PD1.5 (ENA/DIAGA), R44.1; also elsewhere on the board
EA4: PD4.5 (ENA/DIAGA), R77.1; also elsewhere on the board
EB1: PD2.9 (ENB/DIAGB), R41.1; also elsewhere on the board
EB2: PD3.9 (ENB/DIAGB), R72.1; also elsewhere on the board
EB3: PD1.9 (ENB/DIAGB), R40.1; also elsewhere on the board
EB4: PD4.9 (ENB/DIAGB), R73.1; also elsewhere on the board
ENCL1: R57.2; also elsewhere on the board
ENCL2: R85.2; also elsewhere on the board
ENCL3: R54.2; also elsewhere on the board
ENCL4: R86.2; also elsewhere on the board
ERR1: R53.2; also elsewhere on the board
ERR2: R82.2; also elsewhere on the board
ERR3: R49.2; also elsewhere on the board
ERR4: R84.2; also elsewhere on the board
GND: C21.2, C22.2, C23.2, C24.2, C25.N, C26.N, C27.2, C28.2, C29.2, C30.2, C31.N, C32.N, C33.2, CON1.P$2 (2), CON2.P$2 (2), CON3.P$2 (2), CON4.P$2 (2), LED5.K, LED6.K, LED7.K, LED8.K, LED9.K, LED10.K, LED11.K, LED12.K, PD1.18 (GNDB#1), PD1.19 (GNDB#2), PD1.20 (GNDB#3), PD1.26 (GNDA#1), PD1.27 (GNDA#2), PD1.28 (GNDA#3), PD2.18 (GNDB#1), PD2.19 (GNDB#2), PD2.20 (GNDB#3), PD2.26 (GNDA#1), PD2.27 (GNDA#2), PD2.28 (GNDA#3), PD3.18 (GNDB#1), PD3.19 (GNDB#2), PD3.20 (GNDB#3), PD3.26 (GNDA#1), PD3.27 (GNDA#2), PD3.28 (GNDA#3), PD4.18 (GNDB#1), PD4.19 (GNDB#2), PD4.20 (GNDB#3), PD4.26 (GNDA#1), PD4.27 (GNDA#2), PD4.28 (GNDA#3), R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R42.1, R43.1, R46.1, R47.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1, R74.1, R75.1, R78.1, R79.1, R91.1; also elsewhere on the board
M1M: PD2.15 (OUTB#1), PD2.16 (OUTB#2), PD2.21 (OUTB#3), PD2.OUTB#PAD
M1P: PD2.1 (OUTA#1), PD2.25 (OUTA#2), PD2.30 (OUTA#3), PD2.OUTA#PAD
M2M: PD3.15 (OUTB#1), PD3.16 (OUTB#2), PD3.21 (OUTB#3), PD3.OUTB#PAD
M2P: PD3.1 (OUTA#1), PD3.25 (OUTA#2), PD3.30 (OUTA#3), PD3.OUTA#PAD
M3M: PD1.15 (OUTB#1), PD1.16 (OUTB#2), PD1.21 (OUTB#3), PD1.OUTB#PAD
M3P: PD1.1 (OUTA#1), PD1.25 (OUTA#2), PD1.30 (OUTA#3), PD1.OUTA#PAD
M4M: PD4.15 (OUTB#1), PD4.16 (OUTB#2), PD4.21 (OUTB#3), PD4.OUTB#PAD
M4P: PD4.1 (OUTA#1), PD4.25 (OUTA#2), PD4.30 (OUTA#3), PD4.OUTA#PAD
unnamed: LED6.A, R53.1
unnamed: LED9.A, R82.1
unnamed: LED8.A, R57.1
unnamed: LED5.A, R49.1
unnamed: LED10.A, R84.1
unnamed: LED11.A, R85.1
unnamed: LED12.A, R86.1
unnamed: LED7.A, R54.1
unnamed: R90.1, R91.2, R92.2
unnamed: PD2.7 (PWM), R29.2, R47.2
unnamed: PD3.7 (PWM), R59.2, R78.2
unnamed: PD3.4 (INA), R60.2, R74.2
unnamed: PD3.10 (INB), R61.2, R70.2
unnamed: PD3.8 (CS), R64.1, R66.2
unnamed: PD1.7 (PWM), R26.2, R46.2
unnamed: PD1.4 (INA), R27.2, R42.2
unnamed: PD1.10 (INB), R28.2, R38.2
unnamed: PD2.4 (INA), R30.2, R43.2
unnamed: PD2.10 (INB), R31.2, R39.2
unnamed: PD1.8 (CS), R32.1, R34.2
unnamed: PD4.7 (PWM), R62.2, R79.2
unnamed: PD4.4 (INA), R63.2, R75.2
unnamed: PD4.10 (INB), R58.2, R71.2
unnamed: PD4.8 (CS), R65.1, R67.2
unnamed: PD2.8 (CS), R33.1, R35.2
P1@PWM: R29.1; also elsewhere on the board
P2@PWM: R59.1; also elsewhere on the board
P3@PWM: R26.1; also elsewhere on the board
P4@PWM: R62.1; also elsewhere on the board
V+: C23.1, C24.1, C25.P, C26.P, C29.1, C30.1, C31.P, C32.P, PD1.3 (VCC#1), PD1.12 (VBAT), PD1.13 (VCC#2), PD1.23 (VCC#3), PD1.VCC#PAD, PD2.3 (VCC#1), PD2.12 (VBAT), PD2.13 (VCC#2), PD2.23 (VCC#3), PD2.VCC#PAD, PD3.3 (VCC#1), PD3.12 (VBAT), PD3.13 (VCC#2), PD3.23 (VCC#3), PD3.VCC#PAD, PD4.3 (VCC#1), PD4.12 (VBAT), PD4.13 (VCC#2), PD4.23 (VCC#3), PD4.VCC#PAD, R90.2
VM@ANA: C33.1, R92.1; also elsewhere on the board
X1@ENC: CON1.P$3 (3), R48.1; also elsewhere on the board
X2@ENC: CON3.P$3 (3), R80.1; also elsewhere on the board
X3@ENC: CON2.P$3 (3), R50.1; also elsewhere on the board
X4@ENC: CON4.P$3 (3), R87.1; also elsewhere on the board
Y1@ENC: CON1.P$4 (4), R51.1; also elsewhere on the board
Y2@ENC: CON3.P$4 (4), R81.1; also elsewhere on the board
Y3@ENC: CON2.P$4 (4), R52.1; also elsewhere on the board
Y4@ENC: CON4.P$4 (4), R88.1; also elsewhere on the board
Z1: CON1.P$5 (5), R55.1; also elsewhere on the board
Z2: CON3.P$5 (5), R83.1; also elsewhere on the board
Z3: CON2.P$5 (5), R56.1; also elsewhere on the board
Z4: CON4.P$5 (5), R89.1; also elsewhere on the board

Notes on the sheet:
Blue
[電流センサ部] データシートより比例定数Kを7000として計算する。 最大測定可能電流Iは20[A]であり、 基準電圧Eは2.5[V]と仮定する。 すると抵抗値Rは "R=EK/I=2.5[V]*7000/20[A]=875[ohm]" となり875[ohm]である。 しかし市販されていないので 抵抗値Rを820[ohm]とすると最大測定可能電流Iは "I=EK/R=2.5[V]*7000/820[ohm]=21.3[A]" である。 [電流計測LPF] このモータードライバICの最大制御周波数は20[kohm]である。 そのためサンプリング周波数Fを20[kHz]と仮定する。 するとサン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
[モーター電源監視回路] 最大電圧Emax 30[V] 基準電圧Eref 2.5[V] コンデンサ C 1000[pF] 目標遮断周波数 Fc 40[kHz] R12':=R1//R2=1[khom]//10[khom]=0.92[kohm] R3:=1/(2*PI*Fc*C)-R12'=3.01[kohm] R3'=3[kohm]とする。 R'=R1//R2+R3=3.92[kohm] Fc'=1/(2*PI*R'*C)=40.60[kHz]

Board: 2 copper layers, 99.1 x 99.1 mm, 160 parts (5 on the bottom side), 136 nets.

## Code that names these connections

File soft/sa.ioc (part):

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Mcu.Name=STM32F401V(B-C)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32F401VCTx
PA0-WKUP.Signal=S_TIM5_CH1
PA1.Signal=S_TIM5_CH2
PA11.Signal=USB_OTG_FS_DM
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=JTAG_5_pins
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=JTAG_5_pins
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=JTAG_5_pins
PA15.Signal=SYS_JTDI
PA4.Signal=GPIO_Analog
PA5.Signal=GPIO_Analog
PA6.Signal=GPIO_Analog
PA7.Signal=GPIO_Analog
PA8.Signal=GPIO_Input
PA9.Signal=GPIO_Input
PB0.Signal=GPIO_Output
PB1.Signal=GPIO_Output
PB10.Signal=GPIO_Input
PB12.Signal=GPIO_Output
PB13.Signal=GPIO_Output
PB14.Signal=GPIO_Output
PB15.Signal=GPIO_Output
PB2.Signal=GPIO_Input
PB3.Mode=JTAG_5_pins
PB3.Signal=SYS_JTDO-SWO
PB4.Mode=JTAG_5_pins
PB4.Signal=SYS_JTRST
PB5.Signal=GPIO_Input
PB6.Signal=GPIO_Output
PB7.Signal=GPIO_Output
PB8.Signal=S_TIM10_CH1
PB9.Signal=S_TIM11_CH1
PC0.Signal=GPIO_Output
PC1.Signal=GPIO_Output
PC10.Signal=GPIO_Output
PC11.Signal=GPIO_Output
PC12.Signal=GPIO_Output
PC13-ANTI_TAMP.Signal=GPIO_Output
PC14-OSC32_IN.Signal=GPIO_Output
PC15-OSC32_OUT.Signal=GPIO_Output
PC2.Signal=GPIO_Output
PC3.Signal=GPIO_Output
PC4.Signal=GPIO_Analog
PC5.Signal=GPIO_Analog
PC6.Signal=S_TIM3_CH1
PC7.Signal=S_TIM3_CH2
PC8.Signal=GPIO_Input
PC9.Signal=GPIO_Input
PD0.Signal=GPIO_Output
PD1.Signal=GPIO_Output
PD10.Signal=GPIO_Input
PD11.Signal=GPIO_Input
PD12.Signal=S_TIM4_CH1
PD13.Signal=S_TIM4_CH2
PD14.Signal=GPIO_Input
PD15.Signal=GPIO_Input
PD2.Signal=GPIO_Output
PD3.Signal=USART2_CTS
PD4.Signal=USART2_RTS
PD5.Mode=Asynchronous
PD5.Signal=USART2_TX
PD6.Mode=Asynchronous
PD6.Signal=USART2_RX
PD7.Signal=GPIO_Output
PD8.Signal=GPIO_Input
PD9.Signal=GPIO_Input
PE0.Signal=GPIO_Output
PE1.Signal=GPIO_Output
PE10.Signal=GPIO_Output
PE11.Signal=S_TIM1_CH2
PE12.Signal=GPIO_Output
PE13.Signal=GPIO_Output
PE14.Signal=GPIO_Output
PE15.Signal=GPIO_Output
PE2.Signal=GPIO_Output
PE3.Signal=GPIO_Output
PE4.Signal=GPIO_Output
PE5.Signal=S_TIM9_CH1
PE6.Signal=S_TIM9_CH2
PE7.Signal=GPIO_Output
PE8.Signal=GPIO_Output
PE9.Signal=S_TIM1_CH1
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=84000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK

## Commit log

2018-03-15 とりあえずcubemxにて初期設定を作成してみた。マイコンの機能は問題なし。FREERTOSとかのusb関連はまだ。 (おそらく)問題点：UART１のピンの位置が違う可能性あり。あとエンコーダモードはCH3，4しか使えない疑惑(現在ピンはCH1,2)。まずいかも
2018-03-15 プロジェクト名変えただけ

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2015 Accelerated Designs. All rights reserved
